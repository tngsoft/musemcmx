# IAR project musemcmx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c system_stm32f4xx92M.c xHandler.c xxAxel.c xxCustom.c xxEEPROM.c xxencode.c xxInit.c xxIntr.c xxIpUtil.c xxNet.c xxRS485.c xxRtc.c xxSDIO.c xxSpi.c xxSystem.c xxUart.c xxWork.c
  group CMSIS
    ../CMSIS/: startup_stm32f4xx.s
